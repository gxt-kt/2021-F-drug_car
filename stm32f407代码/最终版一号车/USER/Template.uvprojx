# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\FWLIB\inc;..\SYSTEM;..\SYSTEM\oled;..\SYSTEM\pid;..\MOTOR_shuanghuan;..\SYSTEM\ANO_V7;..\SYSTEM\flycontrol_v1;..\SYSTEM\balance_car_bujin;..\SYSTEM\one_fly_contorl;..\SYSTEM\banqiu;..\SYSTEM\gxt_algorithm;..\SYSTEM\fenglibai;..\SYSTEM\balance_car;..\SYSTEM\CHE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../SYSTEM/: my_task.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/: usart1.c exti.c led.c tim6.c tim14.c sonic.c ws2812.c sbus_usart2.c encoder.c qy3806_abs.c tim8.c w25qxx.c spi.c usart3.c adc.c key.c watch_dog.c
    ../SYSTEM/oled/: myiic.c oled.c
  group 国赛车
    ../SYSTEM/CHE/: car_ctrl.c car_init.c car_other.c car_uart1.c car_uart2.c MOTOR_CTRL.c k210it.c ctrl_num.c DRIVER.c task1.c task2.c task3.c
  group MOTOR_双环
    ../MOTOR_shuanghuan/: motor_shuanghuan.c
  group 上位机ANO-v7
    ../SYSTEM/ANO_V7/: send_data.c V7_data_deal.c
  group README
    ../: readme.txt
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group 飞控一代
    ../SYSTEM/flycontrol_v1/: ak8975.c attitude_up.c ICM20602.c imu_spi.c SPL06_001.c
  group 步进电机
    ../SYSTEM/balance_car_bujin/: balance_control.c balance_init.c
  group 单个空心杯角度控制
    ../SYSTEM/one_fly_contorl/: onefly_control.c
  group 板球
    ../SYSTEM/banqiu/: banqiu.c
  group GXT算法
    ../SYSTEM/gxt_algorithm/: my_algorithm.c
  group 风力摆
    ../SYSTEM/fenglibai/: fenglibai.c
  group PID
    ../SYSTEM/pid/: pid.c
  group 平衡车国赛准备
    ../SYSTEM/balance_car/: balance_car.c
